# Keil uVision project demo.uvprojx, settings and files
target cortex-m3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources\cpu;.\Sources\driver;.\Sources\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./Sources/main/: main.c
  group driver
    ./Sources/driver/: board.c gpio.c nvic.c uart.c
  group kernel
    ./Sources/kernel/: cpu_init.c kernel-cm4.lib kernel-cm3.lib
  group cpu
    ./Sources/cpu/: startup_stm32f429_439xx.s STM32F429.lib
target cortex-m4 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources\cpu;.\Sources\driver;.\Sources\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
